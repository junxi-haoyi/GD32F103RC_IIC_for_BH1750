# Keil uVision project IIC_F103.uvprojx, settings and files
target IIC_F103 (ARM-ADS)
  device: GD32F103RC GigaDevice
  output: IIC_F103
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .eide\deps;..\..\User;..\..\Libraries\Include;..\..\CMSIS;..\..\Libraries\Source;..\..\API
  asm define: GD32F10X_HD,USE_STDPERIPH_DRIVER
  library: MicroLIB
  memory RVCT1: RAM 0x08000000 size 0x00040000
  memory RVCT6: RAM 0x20000000 size 0x0000C000
  group USER
    ../../CMSIS/: system_gd32f10x.c
    ../../User/: gd32f10x_it.c gd32f10x_libopt.h main.c systick.c
  group STARTUP
    ../../CMSIS/: startup_gd32f10x_hd.s
  group SRC
    ../../Libraries/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group INCLUDE
    ../../Libraries/Include/: gd32f10x_adc.h gd32f10x_bkp.h gd32f10x_can.h gd32f10x_crc.h gd32f10x_dac.h gd32f10x_dbg.h gd32f10x_dma.h gd32f10x_enet.h gd32f10x_exmc.h gd32f10x_exti.h gd32f10x_fmc.h gd32f10x_fwdgt.h gd32f10x_gpio.h gd32f10x_i2c.h gd32f10x_misc.h gd32f10x_pmu.h gd32f10x_rcu.h gd32f10x_rtc.h gd32f10x_sdio.h gd32f10x_spi.h gd32f10x_timer.h gd32f10x_usart.h gd32f10x_wwdgt.h
  group API
    ../../API/: IIC.c USART.c
